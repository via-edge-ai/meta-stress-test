
RDEPENDS:${PN}:append = " \
	iotop \
	numactl \
	sysstat \
	rt-tests \
	stress-scripts \
"
