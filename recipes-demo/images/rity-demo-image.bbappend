
IMAGE_INSTALL += " \
	stress-scripts \
"
